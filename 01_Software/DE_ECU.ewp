# IAR project DE_ECU.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMS570LS3137ZWT TexasInstruments TMS570LS3137ZWT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 42
  General.FPU2: 3
  ICCARM.CCDiagSuppress: Pa050,
  ICCARM.CCIncludePath2: 01_Code\APP; 01_Code\RTE; 01_Code\APP\app_shared; 01_Code\DIAG; 01_Code\TAPAS\Core\Startup; 01_Code\TAPAS\Core\LIB; 01_Code\TAPAS\Core\Main; 01_Code\TAPAS\Core\OS; 01_Code\TAPAS\Core\UC; 01_Code\TAPAS\Core\UC\adc; 01_Code\TAPAS\Core\UC\can; 01_Code\TAPAS\Core\UC\dio; 01_Code\TAPAS\Core\UC\pwm; 01_Code\TAPAS\Core\UC\spi; 01_Code\TAPAS\Core\UC\system; 01_Code\TAPAS\Core\UC\timer; 01_Code\TAPAS\Core\UC\uart; 01_Code\TAPAS\Core\ECU; 01_Code\TAPAS\Core\ECU\anlg; 01_Code\TAPAS\Core\ECU\com; 01_Code\TAPAS\Core\ECU\io; 01_Code\TAPAS\Core\ECU\mem; 01_Code\TAPAS\Core\ECU\serial; 01_Code\TAPAS\Core\ECU\system; 01_Code\APP\app_SysMgr; 01_Code\APP\app_FaultMgr; 01_Code\APP\app_BatteryMgr; 01_Code\APP\app_ChargingMgr; 01_Code\APP\app_ComMgr; 01_Code\APP\app_DrivingMgr; 01_Code\APP\app_LightMgr; 01_Code\APP\app_AccelMgr; 01_Code\APP\app_BrakeMgr; 01_Code\APP\app_CoolingMgr; 01_Code\APP\app_AirConMgr; 01_Code\APP\app_PowerSteeringMgr; 01_Code\APP\app_DashMgr; 01_Code\APP\app_DcDcMgr; 01_Code\TAPAS\Core\ECU\wdg; 01_Code\TAPAS\Core\UC\wdg; 01_Code\TAPAS\Core\ECU\txcp; 01_Code\TAPAS\Core\ECU\diag; 01_Code\TAPAS\Core\UC\eeprom; 01_Code\TAPAS\Core\UC\flash; 01_Code\TAPAS\Core\LIB\F021 Flash API\02.01.01\include; 01_Code\TAPAS\Core\LIB\F021 Flash API\02.01.01\source; 01_Code\APP\app_GearMgr; 01_Code\APP\app_McuMgr; 01_Code\APP\app_StartKeyMgr; 01_Code\TAPAS\Cfg\DE_ECU\ECU\wdg; 01_Code\TAPAS\Cfg\DE_ECU\OS; 01_Code\TAPAS\Cfg\DE_ECU\UC\adc; 01_Code\TAPAS\Cfg\DE_ECU\UC\can; 01_Code\TAPAS\Cfg\DE_ECU\UC\dio; 01_Code\TAPAS\Cfg\DE_ECU\UC\eeprom; 01_Code\TAPAS\Cfg\DE_ECU\UC\flash; 01_Code\TAPAS\Cfg\DE_ECU\UC\pwm; 01_Code\TAPAS\Cfg\DE_ECU\UC\spi; 01_Code\TAPAS\Cfg\DE_ECU\UC\system; 01_Code\TAPAS\Cfg\DE_ECU\UC\timer; 01_Code\TAPAS\Cfg\DE_ECU\UC\uart; 01_Code\TAPAS\Cfg\DE_ECU\UC\wdg; 01_Code\TAPAS\Core\DIAG; 01_Code\TAPAS\Cfg\DE_ECU\DIAG; 01_Code\APP\app_CamMgr; 01_Code\APP\app_ComMgr; 01_Code\APP\app_PosMgr; 01_Code\APP\app_HmiMgr; 01_Code\APP\app_SteeringMgr; 01_Code\APP\app_VelocityMgr; 01_Code\TAPAS\Core\UC\emac; 01_Code\TAPAS\Cfg\ethernet\UC\emac; 01_Code\TAPAS\Cfg\DE_ECU\ECU\txcp; 01_Code\TAPAS\Cfg\DE_ECU\ECU\serial; 01_Code\TAPAS\Cfg\DE_ECU\ECU\io; 01_Code\TAPAS\Cfg\DE_ECU\ECU\mem; 01_Code\TAPAS\Cfg\DE_ECU\ECU\anlg; 01_Code\TAPAS\Cfg\DE_ECU\ECU\system; 01_Code\TAPAS\Cfg\DE_ECU\ECU\diag; 01_Code\TAPAS\Cfg\DE_ECU\ECU\com
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DE_ECU.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\TMS570LS3137_flash.icf
  ILINK.IlinkAdditionalLibs: 01_Code\TAPAS\Core\LIB\F021 Flash API\02.01.01\F021_API_CortexR4_BE.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    01_Code/APP/: app.c app.h
  group APP/app_CamMgr
    01_Code/APP/app_CamMgr/: app_CamMgr.c app_CamMgr.h app_CamMgr.mdxml app_CamMgr_cfg.c app_CamMgr_cfg.h
  group APP/app_ComMgr
    01_Code/APP/app_ComMgr/: app_ComMgr.c app_ComMgr.h app_ComMgr_data.c app_ComMgr_private.h app_ComMgr_types.h
  group APP/app_FaultMgr
    01_Code/APP/app_FaultMgr/: app_FaultMgr.c app_FaultMgr.h app_FaultMgr.mdxml app_FaultMgr_cfg.c app_FaultMgr_cfg.h
  group APP/app_HmiMgr
    01_Code/APP/app_HmiMgr/: app_HmiMgr.c app_HmiMgr.h app_HmiMgr_data.c app_HmiMgr_private.h app_HmiMgr_types.h
  group APP/app_PosMgr
    01_Code/APP/app_PosMgr/: app_PosMgr.c app_PosMgr.h app_PosMgr_data.c app_PosMgr_private.h app_PosMgr_types.h
  group APP/app_shared
    01_Code/APP/app_shared/: look1_binlxpw.c look1_binlxpw.h rt_nonfinite.c rt_nonfinite.h rt_powd_snf.c rt_powd_snf.h rt_roundd_snf.c rt_roundd_snf.h rtGetInf.c rtGetInf.h rtGetNaN.c rtGetNaN.h rtwtypes.h
  group APP/app_SteeringMgr
    01_Code/APP/app_SteeringMgr/: app_SteeringMgr.c app_SteeringMgr.h app_SteeringMgr_data.c app_SteeringMgr_private.h app_SteeringMgr_types.h
  group APP/app_VelocityMgr
    01_Code/APP/app_VelocityMgr/: app_VelocityMgr.c app_VelocityMgr.h app_VelocityMgr_data.c app_VelocityMgr_private.h app_VelocityMgr_types.h
  group DIAG/cfg
    01_Code/TAPAS/Cfg/DE_ECU/DIAG/: app_diag_cfg.h
  group DIAG/core
    01_Code/TAPAS/Core/DIAG/: app_diag.c app_diag.h app_diag_generic_functions.c app_diag_gf.c app_diag_gf.h
  group ECU
    01_Code/TAPAS/Core/ECU/: ecu.c ecu.h
  group ECU/anlg/cfg
    01_Code/TAPAS/Cfg/DE_ECU/ECU/anlg/: ecu_anlg_cfg.c ecu_anlg_cfg.h
  group ECU/anlg/core
    01_Code/TAPAS/Core/ECU/anlg/: ecu_anlg.c ecu_anlg.h
  group ECU/com/cfg
    01_Code/TAPAS/Cfg/DE_ECU/ECU/com/: ecu_com_cfg.c ecu_com_cfg.h ecu_com_cfg_gen.c ecu_com_cfg_gen.h
  group ECU/com/core
    01_Code/TAPAS/Core/ECU/com/: ecu_com.c ecu_com.h
  group ECU/diag/cfg
    01_Code/TAPAS/Cfg/DE_ECU/ECU/diag/: ecu_diag_cfg.c ecu_diag_cfg.h
  group ECU/diag/core
    01_Code/TAPAS/Core/ECU/diag/: ecu_diag.c ecu_diag.h
  group ECU/io/cfg
    01_Code/TAPAS/Cfg/DE_ECU/ECU/io/: ecu_io_cfg.c ecu_io_cfg.h
  group ECU/io/core
    01_Code/TAPAS/Core/ECU/io/: ecu_io.c ecu_io.h
  group ECU/mem/cfg
    01_Code/TAPAS/Cfg/DE_ECU/ECU/mem/: ecu_mem_cfg.c ecu_mem_cfg.h
  group ECU/mem/core
    01_Code/TAPAS/Core/ECU/mem/: ecu_mem.c ecu_mem.h
  group ECU/serial/cfg
    01_Code/TAPAS/Cfg/DE_ECU/ECU/serial/: ecu_serial_cfg.c ecu_serial_cfg.h
  group ECU/serial/core
    01_Code/TAPAS/Core/ECU/serial/: ecu_serial.c ecu_serial.h
  group ECU/system/cfg
    01_Code/TAPAS/Cfg/DE_ECU/ECU/system/: ecu_system_cfg.c ecu_system_cfg.h
  group ECU/system/core
    01_Code/TAPAS/Core/ECU/system/: ecu_system.c ecu_system.h
  group ECU/txcp/cfg
    01_Code/TAPAS/Cfg/DE_ECU/ECU/txcp/: ecu_txcp_cfg.c ecu_txcp_cfg.h ecu_txcp_cfg_gen.h
  group ECU/txcp/core
    01_Code/TAPAS/Core/ECU/txcp/: ecu_txcp.c ecu_txcp.h
  group ECU/wdg/cfg
    01_Code/TAPAS/Cfg/DE_ECU/ECU/wdg/: ecu_wdg_cfg.c ecu_wdg_cfg.h
  group ECU/wdg/core
    01_Code/TAPAS/Core/ECU/wdg/: ecu_wdg.c ecu_wdg.h
  group LIB
    01_Code/TAPAS/Core/LIB/: lib_data.c lib_data.h lib_delay.c lib_delay.h lib_types.h
  group LIB/F021_API
    01_Code/TAPAS/Core/LIB/F021 Flash API/02.01.01/include/: CGT.IAR.h F021.h
    01_Code/TAPAS/Core/LIB/F021 Flash API/02.01.01/source/: Fapi_UserDefinedFunctions.c
  group Main
    01_Code/TAPAS/Core/Main/: main.c
  group OS/cfg
    01_Code/TAPAS/Cfg/DE_ECU/OS/: os_cfg.c os_cfg.h os_tasks.c os_tasks.h
  group OS/core
    01_Code/TAPAS/Core/OS/: os.c os.h
  group RTE
    01_Code/RTE/: rte.c rte.h rte_app.h rte_tasks.c
  group Startup
    01_Code/TAPAS/Core/Startup/: arm_comm.h low_level_init.c tms570ls3137_cstartup.s
  group UC
    01_Code/TAPAS/Core/UC/: uc.c uc.h uc_header.h
  group UC/adc/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/adc/: uc_adc_cfg.c uc_adc_cfg.h
  group UC/adc/core
    01_Code/TAPAS/Core/UC/adc/: uc_adc.c uc_adc.h
  group UC/can/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/can/: uc_can_cfg.c uc_can_cfg.h
  group UC/can/core
    01_Code/TAPAS/Core/UC/can/: uc_can.c uc_can.h
  group UC/dio/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/dio/: uc_dio_cfg.c uc_dio_cfg.h
  group UC/dio/core
    01_Code/TAPAS/Core/UC/dio/: uc_dio.c uc_dio.h
  group UC/eeprom/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/eeprom/: uc_eeprom_cfg.c uc_eeprom_cfg.h
  group UC/eeprom/core
    01_Code/TAPAS/Core/UC/eeprom/: uc_eeprom.c uc_eeprom.h
  group UC/emac/cfg
    01_Code/TAPAS/Cfg/ethernet/UC/emac/: uc_emac_cfg.c uc_emac_cfg.h
  group UC/emac/core
    01_Code/TAPAS/Core/UC/emac/: uc_emac.c uc_emac.h
  group UC/flash/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/flash/: uc_flash_cfg.c uc_flash_cfg.h
  group UC/flash/core
    01_Code/TAPAS/Core/UC/flash/: uc_flash.c uc_flash.h
  group UC/pwm/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/pwm/: uc_pwm_cfg.c uc_pwm_cfg.h
  group UC/pwm/core
    01_Code/TAPAS/Core/UC/pwm/: uc_pwm.c uc_pwm.h
  group UC/spi/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/spi/: uc_spi_cfg.c uc_spi_cfg.h
  group UC/spi/core
    01_Code/TAPAS/Core/UC/spi/: uc_spi.c uc_spi.h
  group UC/system/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/system/: uc_system_cfg.c uc_system_cfg.h
  group UC/system/core
    01_Code/TAPAS/Core/UC/system/: uc_system.c uc_system.h
  group UC/timer/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/timer/: uc_timer_cfg.c uc_timer_cfg.h
  group UC/timer/core
    01_Code/TAPAS/Core/UC/timer/: uc_timer.c uc_timer.h
  group UC/uart/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/uart/: uc_uart _cfg.c uc_uart_cfg.h
  group UC/uart/core
    01_Code/TAPAS/Core/UC/uart/: uc_uart.c uc_uart.h
  group UC/wdg/cfg
    01_Code/TAPAS/Cfg/DE_ECU/UC/wdg/: uc_wdg_cfg.c uc_wdg_cfg.h
  group UC/wdg/core
    01_Code/TAPAS/Core/UC/wdg/: uc_wdg.c uc_wdg.h
