# IAR project Tapas_Boot.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMS570LS3137ZWT TexasInstruments TMS570LS3137ZWT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 42
  General.FPU2: 3
  ICCARM.CCDiagSuppress: Pa050,
  ICCARM.CCIncludePath2: 01_Code\APP; 01_Code\RTE; 01_Code\APP\app_test; 01_Code\APP\app_shared; 01_Code\APP\app_diag; 01_Code\TAPAS\Core\Startup; 01_Code\TAPAS\Core\LIB; 01_Code\TAPAS\Core\Main; 01_Code\TAPAS\Core\OS; 01_Code\TAPAS\Core\UC; 01_Code\TAPAS\Core\UC\adc; 01_Code\TAPAS\Core\UC\can; 01_Code\TAPAS\Core\UC\dio; 01_Code\TAPAS\Core\UC\pwm; 01_Code\TAPAS\Core\UC\spi; 01_Code\TAPAS\Core\UC\system; 01_Code\TAPAS\Core\UC\timer; 01_Code\TAPAS\Core\UC\uart; 01_Code\TAPAS\Core\ECU; 01_Code\TAPAS\Core\ECU\anlg; 01_Code\TAPAS\Core\ECU\com; 01_Code\TAPAS\Core\ECU\io; 01_Code\TAPAS\Core\ECU\mem; 01_Code\TAPAS\Core\ECU\serial; 01_Code\TAPAS\Core\ECU\system; 01_Code\TAPAS\Cfg\Boot\OS; 01_Code\TAPAS\Cfg\Boot\UC; 01_Code\TAPAS\Cfg\Boot\UC\adc; 01_Code\TAPAS\Cfg\Boot\UC\can; 01_Code\TAPAS\Cfg\Boot\UC\dio; 01_Code\TAPAS\Cfg\Boot\UC\pwm; 01_Code\TAPAS\Cfg\Boot\UC\spi; 01_Code\TAPAS\Cfg\Boot\UC\system; 01_Code\TAPAS\Cfg\Boot\UC\timer; 01_Code\TAPAS\Cfg\Boot\UC\uart; 01_Code\TAPAS\Cfg\Boot\ECU\anlg; 01_Code\TAPAS\Cfg\Boot\ECU\com; 01_Code\TAPAS\Cfg\Boot\ECU\io; 01_Code\TAPAS\Cfg\Boot\ECU\mem; 01_Code\TAPAS\Cfg\Boot\ECU\serial; 01_Code\TAPAS\Cfg\Boot\ECU\system; 01_Code\TAPAS\Cfg\Boot\ECU; 01_Code\TAPAS\Core\ECU\wdg; 01_Code\TAPAS\Cfg\Boot\ECU\wdg; 01_Code\TAPAS\Core\UC\wdg; 01_Code\TAPAS\Cfg\Boot\UC\wdg; 01_Code\TAPAS\Core\UC\eeprom; 01_Code\TAPAS\Cfg\Boot\UC\eeprom; 01_Code\TAPAS\Core\LIB\F021 Flash API\02.01.01; 01_Code\TAPAS\Core\LIB\F021 Flash API\02.01.01\include; 01_Code\TAPAS\Core\LIB\F021 Flash API\02.01.01\source; 01_Code\TAPAS\Core\ECU\mem_int; 01_Code\TAPAS\Cfg\Boot\ECU\mem_int; 01_Code\TAPAS\Core\UC\flash; 01_Code\TAPAS\Cfg\Boot\UC\flash
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Tapas_Boot.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\TMS570LS3137_flash.icf
  ILINK.IlinkAdditionalLibs: 01_Code\TAPAS\Core\LIB\F021 Flash API\02.01.01\F021_API_CortexR4_BE.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    01_Code/APP/: app.c app.h
  group APP/app_test
    01_Code/APP/app_test/: app_test.c app_test.h
  group ECU
    01_Code/TAPAS/Core/ECU/: ecu.c ecu.h
  group ECU/anlg/cfg
    01_Code/TAPAS/Cfg/Boot/ECU/anlg/: ecu_anlg_cfg.c ecu_anlg_cfg.h
  group ECU/anlg/core
    01_Code/TAPAS/Core/ECU/anlg/: ecu_anlg.c ecu_anlg.h
  group ECU/com/cfg
    01_Code/TAPAS/Cfg/Boot/ECU/com/: ecu_com_cfg.c ecu_com_cfg.h ecu_com_cfg_gen.c ecu_com_cfg_gen.h
  group ECU/com/core
    01_Code/TAPAS/Core/ECU/com/: ecu_com.c ecu_com.h
  group ECU/io/cfg
    01_Code/TAPAS/Cfg/Boot/ECU/io/: ecu_io_cfg.c ecu_io_cfg.h
  group ECU/io/core
    01_Code/TAPAS/Core/ECU/io/: ecu_io.c ecu_io.h
  group ECU/mem/cfg
    01_Code/TAPAS/Cfg/Boot/ECU/mem/: ecu_mem_cfg.c ecu_mem_cfg.h
  group ECU/mem/core
    01_Code/TAPAS/Core/ECU/mem/: ecu_mem.c ecu_mem.h
  group ECU/mem_int/cfg
    01_Code/TAPAS/Cfg/Boot/ECU/mem_int/: ecu_mem_int_cfg.c ecu_mem_int_cfg.h
  group ECU/mem_int/core
    01_Code/TAPAS/Core/ECU/mem_int/: ecu_mem_int.c ecu_mem_int.h
  group ECU/serial/cfg
    01_Code/TAPAS/Cfg/Boot/ECU/serial/: ecu_serial_cfg.c ecu_serial_cfg.h
  group ECU/serial/core
    01_Code/TAPAS/Core/ECU/serial/: ecu_serial.c ecu_serial.h
  group ECU/system/cfg
    01_Code/TAPAS/Cfg/Boot/ECU/system/: ecu_system_cfg.c ecu_system_cfg.h
  group ECU/system/core
    01_Code/TAPAS/Core/ECU/system/: ecu_system.c ecu_system.h
  group ECU/wdg/cfg
    01_Code/TAPAS/Cfg/Boot/ECU/wdg/: ecu_wdg_cfg.c ecu_wdg_cfg.h
  group ECU/wdg/core
    01_Code/TAPAS/Core/ECU/wdg/: ecu_wdg.c ecu_wdg.h
  group LIB
    01_Code/TAPAS/Core/LIB/: lib_data.c lib_data.h lib_delay.c lib_delay.h lib_types.h
  group LIB/F021_API
    01_Code/TAPAS/Core/LIB/F021 Flash API/02.01.01/include/: CGT.IAR.h F021.h
    01_Code/TAPAS/Core/LIB/F021 Flash API/02.01.01/source/: Fapi_UserDefinedFunctions.c
  group Main
    01_Code/TAPAS/Core/Main/: main.c
  group OS/cfg
    01_Code/TAPAS/Cfg/Boot/OS/: os_cfg.c os_cfg.h
  group OS/core
    01_Code/TAPAS/Core/OS/: os.c os.h os_tasks.c os_tasks.h
  group RTE
    01_Code/RTE/: rte.c rte.h rte_app.h rte_tasks.c
  group Startup
    01_Code/TAPAS/Core/Startup/: arm_comm.h low_level_init.c tms570ls3137_cstartup.s
  group UC
    01_Code/TAPAS/Core/UC/: uc.c uc.h uc_header.h
  group UC/adc/cfg
    01_Code/TAPAS/Cfg/Boot/UC/adc/: uc_adc_cfg.c uc_adc_cfg.h
  group UC/adc/core
    01_Code/TAPAS/Core/UC/adc/: uc_adc.c uc_adc.h
  group UC/can/cfg
    01_Code/TAPAS/Cfg/Boot/UC/can/: uc_can_cfg.c uc_can_cfg.h
  group UC/can/core
    01_Code/TAPAS/Core/UC/can/: uc_can.c uc_can.h
  group UC/dio/cfg
    01_Code/TAPAS/Cfg/Boot/UC/dio/: uc_dio_cfg.c uc_dio_cfg.h
  group UC/dio/core
    01_Code/TAPAS/Core/UC/dio/: uc_dio.c uc_dio.h
  group UC/eeprom/cfg
    01_Code/TAPAS/Cfg/Boot/UC/eeprom/: uc_eeprom_cfg.c uc_eeprom_cfg.h
  group UC/eeprom/core
    01_Code/TAPAS/Core/UC/eeprom/: uc_eeprom.c uc_eeprom.h
  group UC/flash/cfg
    01_Code/TAPAS/Cfg/Boot/UC/flash/: uc_flash_cfg.c uc_flash_cfg.h
  group UC/flash/core
    01_Code/TAPAS/Core/UC/flash/: uc_flash.c uc_flash.h
  group UC/pwm/cfg
    01_Code/TAPAS/Cfg/Boot/UC/pwm/: uc_pwm_cfg.c uc_pwm_cfg.h
  group UC/pwm/core
    01_Code/TAPAS/Core/UC/pwm/: uc_pwm.c uc_pwm.h
  group UC/spi/cfg
    01_Code/TAPAS/Cfg/Boot/UC/spi/: uc_spi_cfg.c uc_spi_cfg.h
  group UC/spi/core
    01_Code/TAPAS/Core/UC/spi/: uc_spi.c uc_spi.h
  group UC/system/cfg
    01_Code/TAPAS/Cfg/Boot/UC/system/: uc_system_cfg.c uc_system_cfg.h
  group UC/system/core
    01_Code/TAPAS/Core/UC/system/: uc_system.c uc_system.h
  group UC/timer/cfg
    01_Code/TAPAS/Cfg/Boot/UC/timer/: uc_timer_cfg.c uc_timer_cfg.h
  group UC/timer/core
    01_Code/TAPAS/Core/UC/timer/: uc_timer.c uc_timer.h
  group UC/uart/cfg
    01_Code/TAPAS/Cfg/Boot/UC/uart/: uc_uart _cfg.c uc_uart_cfg.h
  group UC/uart/core
    01_Code/TAPAS/Core/UC/uart/: uc_uart.c uc_uart.h
